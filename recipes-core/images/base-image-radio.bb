DESCRIPTION = "Basic Projet Monitoring"
LICENSE = "MIT"

inherit core-image





