# Customization of dnsmasq

# Files directory
FILESEXTRAPATHS_prepend := "${THISDIR}/dnsmasq:"